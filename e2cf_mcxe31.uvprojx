# Keil uVision project e2cf_mcxe31.uvprojx, settings and files
target e2cf_mcxe31 debug (6230000::V6.23::ARMCLANG)
  device: MCXE31BMPB NXP
  pack: NXP.MCXE31B_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: e2cf_mcxe31.out
  AfterMake: fromelf.exe --output "$Lflexcan_interrupt_transfer.bin" --bincombined "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, FLEXCAN_WAIT_TIMEOUT=1000, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES, BOOT_HEADER_ENABLE=1
  c misc: -include source/mcux_config.h -include source/mcuxsdk_version.h -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;CMSIS/m-profile;boot_header;component/uart;component/phy;component/phy/device/phylan8741;component/silicon_id;component/silicon_id/socs;component/silicon_id/socs/mcxe31x;device;device/periph1;drivers;utilities;utilities/debug_console_lite;utilities/str
  asm define: MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES
  asm include: source;CMSIS;CMSIS/m-profile;boot_header;component/uart;component/phy;component/phy/device/phylan8741;component/silicon_id;component/silicon_id/socs;component/silicon_id/socs/mcxe31x;device;device/periph1;drivers;utilities;utilities/debug_console_lite;utilities/str
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x21400000 size 0x10000
  memory RVCT7: RAM 0x0 size 0x8000
  memory RVCT8: RAM 0x11400000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MCXE31B/mdk/MCXE31B_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group boot_header
    boot_header/: boot_header.c boot_header.h
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    CMSIS/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXE31B.h MCXE31B_COMMON.h MCXE31B_features.h system_MCXE31B.c system_MCXE31B.h
  group device/periph1
    device/periph1/: PERI_ADC.h PERI_AXBS_LITE.h PERI_BCTU.h PERI_CAN.h PERI_CMU_FC.h PERI_CMU_FM.h PERI_CONFIGURATION.h PERI_CRC.h PERI_DCM.h PERI_DCM_GPR.h PERI_DMA.h PERI_DMAMUX.h PERI_EIM.h PERI_EMAC.h PERI_EMIOS.h PERI_ERM.h PERI_FCCU.h PERI_FIRC.h PERI_FLASH.h PERI_FLEXIO.h PERI_FXOSC.h PERI_I2S.h PERI_INTM.h PERI_JDC.h PERI_LCU.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MC_CGM.h PERI_MC_ME.h PERI_MC_RGM.h PERI_MCM.h PERI_MDM_AP.h PERI_MSCM.h PERI_MU.h PERI_PFLASH.h PERI_PIT.h PERI_PLL.h PERI_PMC.h PERI_PRAMC.h PERI_QUADSPI.h PERI_QUADSPI_ARDB.h PERI_RTC.h PERI_SDA_AP.h PERI_SELFTEST.h PERI_SEMA42.h PERI_SIRC.h PERI_SIUL2.h PERI_STCU.h PERI_STM.h PERI_SWT.h PERI_SXOSC.h PERI_TEMPSENSE.h PERI_TRGMUX.h PERI_TSPC.h PERI_VIRT_WRAPPER.h PERI_WKPU.h PERI_XBIC.h PERI_XRDC.h
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_enet_qos.c fsl_enet_qos.h fsl_flexcan.c fsl_flexcan.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_siul2.c fsl_siul2.h
  group source
    source/: can_hw.c can_hw.h dbg_log.c dbg_log.h e2cf_config.h e2cf_core.c e2cf_core.h e2cf_proto.h eth_raw.c eth_raw.h gw_prof.c gw_prof.h gw_time.c gw_time.h main.c mcux_config.h
  group component/silicon_id
    component/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    component/silicon_id/socs/mcxe31x/: fsl_silicon_id_soc.c
    component/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/phy
    component/phy/: fsl_phy.h
    component/phy/device/phylan8741/: fsl_phylan8741.c fsl_phylan8741.h
  group startup
    startup/: startup_MCXE31B.c
  group utilities/debug_console_lite
    utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_memcpy.S
  group utilities/str
    utilities/str/: fsl_str.c fsl_str.h
